# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include;.\user_code;.\user_config
  group Source Group 1
    ./: STARTUP.A51
    ./user_code/: main.c entry.c entry.h
    ./user_config/: time.c time.h delay.c delay.h uart.c uart.h head.h eeprom.c eeprom.h
    ./include/: oled.c oled.h oledfont.h display.c display.h ds1302.c ds1302.h key.c key.h ds18b20.c ds18b20.h pid.c pid.h
